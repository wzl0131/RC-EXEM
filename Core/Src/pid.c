/* ============================================================================
 * pid.c  ——  PID 控制器模块（实现文件）
 * ----------------------------------------------------------------------------
 * 接口（有什么）在 pid.h 里，本文件写"怎么做"
 *
 * PID 公式（位置式）：
 *
 *   输出 = P项 + I项 + D项
 *        = kp × 误差                    ← 误差越大，拉得越猛
 *        + ki × Σ(误差 × dt)            ← 把历史误差攒起来，消除稳态误差
 *        - kd × d(测量值)/dt            ← 测量值变化越快，越要"提前刹车"
 *
 *   误差 = 目标值(target) - 测量值(actual)
 *
 * ⭐ 本实现的两个工程细节（跟课本的裸 PID 不同）：
 *   ① D 项是"微分先行"：对【测量值】微分，不对【误差】微分
 *      → 目标值突然跳变时不会产生"微分冲击"
 *      → 用摇杆控制时这一点非常重要（你每次推杆目标都会跳）
 *   ② 积分限幅：积分累计被夹在 ±i_max 内（抗积分饱和 wind-up）
 * ==========================================================================*/

#include "pid.h"
#include <string.h>       /* memset() */


/* ============================================================================
 * 全局变量【定义】（对应的 extern 声明在 pid.h 里）
 * ==========================================================================*/
Pid_t pid_speed;        /* 速度环（内环）：rpm   → 电流 */
Pid_t pid_angle;        /* 位置环（外环）：度    → 目标 rpm */


/* ============================================================================
 * 内部小工具：判断两个浮点数是否"足够接近"
 * ----------------------------------------------------------------------------
 * 浮点数不能用 == 比较！因为 0.1f + 0.2f 不一定等于 0.3f
 * → 自测里必须给一个"允许误差"
 * ==========================================================================*/
static int FloatClose(float a, float b, float tol)
{
    float d = a - b;
    if (d < 0.0f) { d = -d; }      /* 取绝对值，不想引入 math.h */
    return (d <= tol) ? 1 : 0;
}


/* ============================================================================
 * 一、初始化
 * ==========================================================================*/
void Pid_Init(Pid_t *p, float kp, float ki, float kd, float out_max, float i_max)
{
    /* 先把整个结构体清零
     *   ⭐ float 的"全 0 二进制"正好表示 0.0f（IEEE754 规定）
     *   → 所以 memset 对 float 也是安全的，integral / last_actual 都归 0 */
    memset(p, 0, sizeof(Pid_t));//清零

    /* 再填入参数 */
    p->kp      = kp;
    p->ki      = ki;
    p->kd      = kd;
    p->out_max = out_max;
    p->i_max   = i_max;
}


/* ============================================================================
 * 二、清空内部状态（切换档位时调用）
 * ----------------------------------------------------------------------------
 * ⚠️ 注意：故意【不】清 last_actual！
 *
 * 为什么？看 D 项：
 *     d_out = -kd × (actual - last_actual) / dt
 *
 *   如果 Pid_Reset 把 last_actual 清成 0，而电机此刻正在转（actual = 200）
 *     → d_actual = (200 - 0) / 0.001 = 200000
 *     → d_out = -kd × 200000 = 一个巨大的冲击 ❌
 *
 *   保留 last_actual，切换档位时 D 项就是平滑的 ✓
 * ==========================================================================*/
void Pid_Reset(Pid_t *p)
{
    p->integral = 0.0f;
    p->p_out    = 0.0f;
    p->i_out    = 0.0f;
    p->d_out    = 0.0f;
    p->output   = 0.0f;
    /* p->last_actual 不动！ */
}


/* ============================================================================
 * 二点五、把 last_actual 同步成当前测量值
 * ----------------------------------------------------------------------------
 * 为什么需要这个函数？
 *
 *   位置环 pid_angle 只在【位置模式】下被 Pid_Calc() 调用，
 *   在速度模式/停机模式下不会被调用 → last_actual 停在"上次位置模式的角度"。
 *
 *   如果这时切回位置模式：
 *       d_actual = (当前角度 - 很久以前的角度) / dt
 *                = 比如 (90 - 0) / 0.001 = 90000
 *       d_out    = -kd × 90000 = 一个巨大的冲击 ❌
 *
 *   → 所以在非位置模式下，每个周期都调一次这个函数，把 last_actual 保持新鲜
 * ==========================================================================*/
void Pid_SyncActual(Pid_t *p, float actual)
{
    p->last_actual = actual;
}


/* ============================================================================
 * 三、算一次 PID 输出
 * ----------------------------------------------------------------------------
 *   target : 目标值（想要的）
 *   actual : 测量值（现在的）
 *   dt     : 距上次调用过了多少【秒】
 *            1 kHz 控制周期 → 传 0.001f
 *            100 Hz         → 传 0.01f
 *
 * 返回值 = 限幅后的输出（同时也存在 p->output 里）
 * ==========================================================================*/
float Pid_Calc(Pid_t *p, float target, float actual, float dt)
{
    float error;        /* 误差 = 目标 - 实际 */
    float d_actual;     /* 测量值的变化率 */

    /* ---- 保护：dt 不能是 0 或负数，否则下面要除以 0 ---- */
    if (dt <= 0.0f)
    {
        dt = 0.001f;
    }

    error = target - actual;

    /* ---- 第 1 项：P（比例）----
     * 误差越大，输出越大。只有 P 的话，最后会停在"误差不为 0"的地方（静差）*/
    p->p_out = p->kp * error;

    /* ---- 第 2 项：I（积分）----
     * 把历次误差 ×dt 一点点攒起来
     * 效果：只要还有误差，积分就会一直涨，直到把静差顶掉
     *
     * ⚠️ 积分必须限幅！否则电机被堵住时误差一直很大，
     *    积分会涨到天文数字；等堵转解除，电机就会"暴冲" */
    p->integral += p->ki * error * dt;

    if (p->integral >  p->i_max) { p->integral =  p->i_max; }
    if (p->integral < -p->i_max) { p->integral = -p->i_max; }

    p->i_out = p->integral;

    /* ---- 第 3 项：D（微分）—— 微分先行 ----
     * 课本写法是 kd × (误差 - 上次误差)/dt，但那样子目标值一跳就会爆
     * 这里改成对【测量值】微分：
     *     测量值涨得越快 → d_actual 越大 → d_out 越是往反方向拉（提前刹车）
     *
     * 例：actual 从 0 涨到 10，dt = 0.01s
     *     d_actual = (10-0)/0.01 = 1000
     *     d_out    = -kd × 1000     ← 负的，和"上涨"反方向 ✓ */
    d_actual = (actual - p->last_actual) / dt;
    p->d_out = -p->kd * d_actual;
    p->last_actual = actual;        /* 记下来，给下一次用 */

    /* ---- 求和 ---- */
    p->output = p->p_out + p->i_out + p->d_out;

    /* ---- 输出限幅：绝不能超过下游能接受的范围 ----
     * 速度环的 out_max = 16384（电调电流上限）
     * 位置环的 out_max = 300  （允许的最大输出轴 rpm）*/
    if (p->output >  p->out_max) { p->output =  p->out_max; }
    if (p->output < -p->out_max) { p->output = -p->out_max; }

    return p->output;
}


/* ============================================================================
 * 四、自测函数（不需要电机、不需要遥控器，纯数学验证）
 *   返回 0 = 通过；返回非 0 表示第几项失败
 *
 * 思路和 C620_SelfTest 一样：
 *   我自己造一组输入，因为我知道正确答案应该是多少
 *   → 算出来跟预期一比，就知道 PID 数学对不对
 * ==========================================================================*/
int Pid_SelfTest(void)
{
    Pid_t t;

    /* ================= ① P 项：kp=2，误差=10 → 输出 20 ================= */
    Pid_Init(&t, 2.0f, 0.0f, 0.0f, 5000.0f, 5000.0f);
    Pid_Calc(&t, 10.0f, 0.0f, 0.001f);          /* 目标 10，实际 0，误差 10 */
    if (!FloatClose(t.p_out,  20.0f, 0.01f)) { return 1; }   /* 2 × 10 = 20 */
    if (!FloatClose(t.output, 20.0f, 0.01f)) { return 2; }   /* ki=kd=0，只有 P */

    /* ================= ② I 项：ki=100，误差=10，dt=0.01 → 每次加 10 ================= */
    Pid_Init(&t, 0.0f, 100.0f, 0.0f, 5000.0f, 5000.0f);
    Pid_Calc(&t, 10.0f, 0.0f, 0.01f);           /* 积分 0 → 100×10×0.01 = 10 */
    if (!FloatClose(t.output, 10.0f, 0.01f)) { return 3; }
    Pid_Calc(&t, 10.0f, 0.0f, 0.01f);           /* 积分 10 → 20 */
    if (!FloatClose(t.output, 20.0f, 0.01f)) { return 4; }

    /* ================= ③ 积分限幅：i_max=15，应该被夹住 ================= */
    Pid_Init(&t, 0.0f, 100.0f, 0.0f, 5000.0f, 15.0f);   /* 注意 i_max = 15 */
    Pid_Calc(&t, 10.0f, 0.0f, 0.01f);           /* 想加到 10 */
    Pid_Calc(&t, 10.0f, 0.0f, 0.01f);           /* 想加到 20 → 被夹到 15 */
    if (!FloatClose(t.output, 15.0f, 0.01f)) { return 5; }
    Pid_Calc(&t, 10.0f, 0.0f, 0.01f);           /* 再想加 → 还是 15 */
    if (!FloatClose(t.output, 15.0f, 0.01f)) { return 6; }

    /* ================= ④ 输出限幅：P 项算出 20，但 out_max=5 → 夹到 5 ================= */
    Pid_Init(&t, 2.0f, 0.0f, 0.0f, 5.0f, 5000.0f);      /* 注意 out_max = 5 */
    Pid_Calc(&t, 10.0f, 0.0f, 0.001f);
    if (!FloatClose(t.p_out,   20.0f, 0.01f)) { return 7; }  /* P 项本身还是 20 */
    if (!FloatClose(t.output,   5.0f, 0.01f)) { return 8; }  /* 但输出被夹到 5 */

    /* ================= ⑤ D 项（微分先行）=================
     * kd=1，测量值从 0 跳到 10，dt=0.01
     *   d_actual = (10-0)/0.01 = 1000
     *   d_out    = -1 × 1000 = -1000   ← 往"下降"方向拉，即提前刹车 */
    Pid_Init(&t, 0.0f, 0.0f, 1.0f, 5000.0f, 5000.0f);
    Pid_Calc(&t, 0.0f, 0.0f, 0.01f);            /* 第一次：测量值没变 → D = 0 */
    if (!FloatClose(t.d_out, 0.0f, 0.01f)) { return 9; }
    Pid_Calc(&t, 0.0f, 10.0f, 0.01f);           /* 测量值涨了 10 → D = -1000 */
    if (!FloatClose(t.d_out, -1000.0f, 0.01f)) { return 10; }

    /* ================= ⑥ Pid_Reset 不清 last_actual（避免微分冲击）=================
     * 如果 Pid_Reset 把 last_actual 清了，下面这次会算出 d_out = -1000（冲击）
     * 保留它 → 测量值没变化 → d_out = 0 ✓ */
    Pid_Init(&t, 0.0f, 0.0f, 1.0f, 5000.0f, 5000.0f);
    Pid_Calc(&t, 0.0f, 10.0f, 0.01f);           /* 让 last_actual 变成 10 */
    Pid_Reset(&t);
    Pid_Calc(&t, 0.0f, 10.0f, 0.01f);           /* 测量值还是 10 → 不应该有冲击 */
    if (!FloatClose(t.output, 0.0f, 0.01f)) { return 11; }

    return 0;       /* 全部通过 */
}
